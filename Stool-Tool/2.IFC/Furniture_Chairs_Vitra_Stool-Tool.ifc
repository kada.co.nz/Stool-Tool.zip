Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-06-19T17:06:18
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 19 17:06:18 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{DF849D92-F006-4F33-9AB6-3F74868CA0EF}\ifc * Database version: 5507 * Database creation date: Fri Jun 19 17:06:16 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 19 17:06:17 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 19 17:06:17 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Stool-Tool, Furniture_Chairs_Vitra_Stool-Tool:Stool-Tool:331231
In: Level 1
Type - Material: 24, light grey
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Chairs_Vitra_Stool-Tool; ConvergoRefNr: 0089-2006-0011-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Stool-Tool resembles a monolithic sculpture and invites users to spontaneously try out its many options. Intuitive use reveals numerous seating positions and possible functions as a small work or storage surface. Lightweight and stackable, the Stool-Tool also has a cutout handle that makes it easy to pick up and store away.; Revision: n/a; Uniclass2: Pr_40_50_12_83; Uniclass2015Description: Stools; Uniclass2015Reference: Pr_40_50_12_85; Version: 1; VersionDate: 17/06/2020
Type - Identity Data(Type) - Cost: 0; Design: Konstantin Grcic, 2016; Manufacturer: Vitra; Model: Stool-Tool; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Product Datasheet: https://www.vitra.com/en-gb/_storage/asset/1943635/storage/master/download/FS_Stool_Tool-EN.pdf; Type Name: Stool-Tool; URL: https://www.vitra.com/en-gb/product/stool-tool; Weight: 5 kg
Type - Other(Type) - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Chairs_Vitra_Stool-Tool; Features: Up to 10 units can be stacked on the floor, incl. stacking protectors; Finish: Special additives retard the fading of colours due to UV radiation; Grade: n/a; Material: Polyproylene; ModelNumber: 09182402; ModelReference: n/a; Name: Vitra_Stool-Tool; ReplacementCost: n/a; Shape: Sculptured; Size: 430/460x725x750mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.22225 m2; Volume: 0.250125 m3
Materials and Finishes - ChairMainMaterial: 24, light grey
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Chairs_Vitra_Stool-Tool: Stool-Tool; Family and Type: Furniture_Chairs_Vitra_Stool-Tool: Stool-Tool; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Chairs_Vitra_Stool-Tool: Stool-Tool; Type Id: Furniture_Chairs_Vitra_Stool-Tool: Stool-Tool; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
